# Keil uVision project Tim.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Tim +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Delay.c Delay.h Key.c Key.h main.c MatrixKey.c MatrixKey.h Nixie.c Nixie.h Timer.c Timer.h AT24C02.c AT24C02.h I2C.c I2C.h
